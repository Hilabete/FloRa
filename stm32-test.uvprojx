# Keil uVision project stm32-test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-test
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_BAND_868, LOW_POWER_MODE_ENABLE, FLORA_BOARD, USE_STM32L152_EVAL
  c include: .\STM32L1xx_StdPeriph_Lib_V1.3.1\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\STM32L1xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Include;.\STM32L1xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Device\ST\STM32L1xx\Include;.\includes;.\STM32_EVAL\Common;.\STM32_EVAL\STM32L152_EVAL;.\mac;.\board;.\radio;.\radio\sx1272;.\utils;.\system;.\system\crypto
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group sources
    ./: main.c
  group std_periphDriver
    ./STM32L1xx_StdPeriph_Lib_V1.3.1/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    ./STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group startup
    ./: startup_stm32l1xx_mdp.s
  group CMSIS
    ./: system_stm32l1xx.c
  group mac
    ./mac/: LoRaMac.c LoRaMacCrypto.c
  group board
    ./board/: board.c gpio-board.c rtc-board.c spi-board.c sx1272-board.c timer-board.c
  group radio
    ./radio/sx1272/: sx1272.c
  group utils
    ./utils/: utilities.c
  group system
    ./system/: delay.c fifo.c gpio.c timer.c
    ./system/crypto/: aes.c cmac.c
